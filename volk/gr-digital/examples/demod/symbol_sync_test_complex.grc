options:
  parameters:
    author: Andy Walls
    category: Custom
    generate_options: qt_gui
    id: symbol_sync_test_float
    output_language: python
    title: Symbol Sync Test (Float)
  states: {}

blocks:
- name: baud_rate
  id: variable
  parameters:
    value: '1200.0'
  states: {}
- name: data_src
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,1
    label: Data Source
    label0: Random
    label1: Low freq
    label2: Dot Pattern
    label3: Pulse
    label4: Packets
    num_opts: '5'
    option0: (0,0,0,0,1)
    option1: (0,1,0,0,0)
    option2: (0,0,1,0,0)
    option3: (0,0,0,1,0)
    option4: (0,0,0,0,1)
    type: raw
    value: (0,0,0,0,1)
  states: {}
- name: integral_gain
  id: variable
  parameters:
    value: 2.0/ted_gain*(1.0-math.exp(-zeta*omega_n_norm)*(math.sinh(zeta*omega_n_norm)+(math.cosh(omega_d_norm) if zeta > 1.0 else math.cos(omega_d_norm))))
  states: {}
- name: integral_gain_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,2,1,1
    label: Integral Gain
    type: string
    value: '"%8.6f" % integral_gain'
  states: {}
- name: omega_d_norm
  id: variable
  parameters:
    value: omega_n_norm*math.sqrt((zeta*zeta-1.0) if zeta > 1.0 else (1.0-zeta*zeta))
  states: {}
- name: omega_n_norm
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: Normalized Bandwidth
    orient: Qt.Horizontal
    start: '0.0'
    step: '0.001'
    stop: 2.0*math.pi*0.25
    value: '0.125'
  states: {}
- name: osps
  id: variable
  parameters:
    value: '1'
  states: {}
- name: packet_time_est_tag
  id: variable_tag_object
  parameters:
    key: pmt.intern("test")
    offset: '9'
    src: pmt.intern("packet_vector_source")
    value: pmt.from_double(0.0)
  states: {}
- name: proportional_gain
  id: variable
  parameters:
    value: 2.0/ted_gain*math.exp(-zeta*omega_n_norm)*math.sinh(zeta*omega_n_norm)
  states: {}
- name: proportional_gain_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 1,2,1,1
    label: Proportional Gain
    type: string
    value: '"%8.6f" % proportional_gain'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '7'
  states: {}
- name: ted_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Expected TED Gain
    orient: Qt.Horizontal
    start: '0.05'
    step: '0.01'
    stop: '5.0'
    value: '0.28365'
  states: {}
- name: zeta
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Damping Factor
    orient: Qt.Horizontal
    start: '0.1'
    step: '0.1'
    stop: '5.0'
    value: '1.0'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '16384'
    repeat: 'True'
    type: short
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_3
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 0.707+0.707j
    type: complex
  states: {}
- name: blocks_multiply_matrix_xx_0
  id: blocks_multiply_matrix_xx
  parameters:
    A: (data_src,)
    tag_propagation_policy: gr.TPP_ALL_TO_ALL
    type: float
  states: {}
- name: blocks_repeat_0_0
  id: blocks_repeat
  parameters:
    comment: Pulse Shaping
    interp: sps*2
    type: float
  states: {}
- name: blocks_short_to_float_1
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: baud_rate*10
    type: float
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: (0, 1, 0, 1, 0, 1, 0, 1)
  states: {}
- name: blocks_vector_source_x_0_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: (0,0,0,0,1,1,1,1)
  states: {}
- name: blocks_vector_source_x_0_0_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[1]+[0]*7'
  states: {}
- name: blocks_vector_source_x_0_0_1_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    tags: '[packet_time_est_tag]'
    type: float
    vector: '[1,0]*(4*12*0)+[1,1,0,1,0,1,0,1]*12+[1,0,1,1,1,1,1,0,0,1]+[1,1,1,1,0,1,1,0,0,1]+[1,0,1,1,1,1,1,0,0,1]+[0,1,1,1,0,1,1,0,1,0]+[0,0,0,0,0,1,0,1,0,1,1,0,0,1,1,1,0,0,0,0]+[2]*128'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: zeta
    loop_bw: omega_n_norm
    max_dev: '1.5'
    osps: osps
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: ted_gain
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from luowaveradio import gr

      class ConstMap(gr.sync_block):
          """
          Map 0, 1 to -1, 1
          """
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='Bit -> Symbol Map',
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )

          def work(self, input_items, output_items):
              """
              map
              """
              sym_map = {0.0: -1.0, 1.0: 1.0, 2.0: 0.0}
              output_items[0][:] = [sym_map[x] for x in input_items[0]]
              return len(output_items[0])
    comment: BPSK Modulation
  states: {}
- name: fir_filter_xxx_0_1_0_0_0_0
  id: fir_filter_xxx
  parameters:
    comment: |-
      Matched Filter (almost). 
      Because the input stream has 6 2/3 
      samples per symbol, this incurs a slight ISI.
    decim: '1'
    samp_delay: int((sps-1.0)/2.0)+4
    taps: '[1.0/float(sps)]*sps'
    type: fff
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from luowaveradio import digital
  states: {}
- name: note_0
  id: note
  parameters:
    note: Bit Pattern Generation
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    color1: '"blue"'
    color2: '"magenta"'
    color3: '"red"'
    color4: '"green"'
    color5: '"black"'
    color6: '"yellow"'
    gui_hint: 3,1,1,2
    label1: Soft Bits Re
    label2: Soft Bits Im
    label3: Error
    label4: Instantaneous Period
    label5: Average Period
    label6: (unused)
    marker1: '1'
    marker2: '0'
    name: Symbol Synched Output and Debug
    nconnections: '3'
    size: 256*osps
    srate: baud_rate*osps
    style6: '0'
    tr_delay: '0.01'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_NORM
    tr_tag: '"time_est"'
    type: complex
    update_time: '0.1'
    ymax: sps+2
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    color1: '"blue"'
    color2: '"red"'
    grid: 'True'
    gui_hint: 3,0,1,1
    label1: ''
    label2: ''
    size: 1024*3
    srate: baud_rate*sps
    tr_delay: '0.01'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_NORM
    tr_tag: ''
    type: complex
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    comment: |-
      Resampling to 6 2/3 samples 
      per symbol ("clock desync")
    decim: '21'
    fbw: '0.45'
    interp: '10'
    taps: ''
    type: fff
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_short_to_float_1, '0']
- [blocks_float_to_complex_0_0, '0', qtgui_time_sink_x_0_0_0_0_0_0, '1']
- [blocks_float_to_complex_1_0, '0', qtgui_time_sink_x_0_0_0_0_0_0, '2']
- [blocks_float_to_complex_3, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_const_vxx_1, '0', digital_symbol_sync_xx_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_time_sink_x_0_1_0, '0']
- [blocks_multiply_matrix_xx_0, '0', blocks_throttle_0, '0']
- [blocks_repeat_0_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_short_to_float_1, '0', blocks_multiply_matrix_xx_0, '0']
- [blocks_throttle_0, '0', epy_block_0_0, '0']
- [blocks_vector_source_x_0_0, '0', blocks_multiply_matrix_xx_0, '2']
- [blocks_vector_source_x_0_0_0, '0', blocks_multiply_matrix_xx_0, '1']
- [blocks_vector_source_x_0_0_1, '0', blocks_multiply_matrix_xx_0, '3']
- [blocks_vector_source_x_0_0_1_0, '0', blocks_multiply_matrix_xx_0, '4']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_0_0_0_0_0_0, '0']
- [digital_symbol_sync_xx_0, '1', blocks_float_to_complex_0_0, '0']
- [digital_symbol_sync_xx_0, '2', blocks_float_to_complex_0_0, '1']
- [digital_symbol_sync_xx_0, '3', blocks_float_to_complex_1_0, '0']
- [epy_block_0_0, '0', blocks_repeat_0_0, '0']
- [fir_filter_xxx_0_1_0_0_0_0, '0', blocks_float_to_complex_3, '0']
- [rational_resampler_xxx_0_0, '0', fir_filter_xxx_0_1_0_0_0_0, '0']

metadata:
  file_format: 1
