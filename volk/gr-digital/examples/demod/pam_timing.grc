options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: pam_timing
    output_language: python
  states: {}

blocks:
- name: const
  id: variable
  parameters:
    value: digital.qpsk_constellation()
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,2,1,1
    label: Frequency Offset
    orient: Qt.Horizontal
    start: '-.5'
    step: '.01'
    stop: '.5'
    value: '0'
  states: {}
- name: interpratio
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,2,1,1
    label: Timing Offset
    orient: Qt.Horizontal
    start: '.99'
    step: '0.0001'
    stop: '1.01'
    value: '1'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_amp
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,2,1,1
    label: Channel Noise
    orient: Qt.Horizontal
    start: '0'
    step: '.001'
    stop: '1'
    value: '0'
  states: {}
- name: rolloff
  id: variable
  parameters:
    value: '.35'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sig_amp
  id: variable
  parameters:
    value: '1'
  states: {}
- name: spb
  id: variable
  parameters:
    value: '4.2563'
  states: {}
- name: time_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,2,1,1
    label: Timing Loop BW
    orient: Qt.Horizontal
    start: '0'
    step: '.001'
    stop: '.1'
    value: '0'
  states: {}
- name: analog_random_source_x
  id: analog_random_source_x
  parameters:
    max: const.arity()
    min: '0'
    num_samps: '10000000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: sig_amp
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: interpratio
    freq_offset: freq_offset
    noise_voltage: noise_amp
    seed: '42'
    taps: '1.0'
  states: {}
- name: digital_chunks_to_symbols_xx
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: const.points()
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: '0'
    loop_bw: time_bw
    max_dev: '1.5'
    osps: '1'
    sps: spb
    taps: firdes.root_raised_cosine(nfilts, nfilts*spb, 1.0, rolloff, 44*nfilts)
    type: ccf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from luowaveradio import digital
  states: {}
- name: notebook
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,1,5,1
    label0: Error
    label1: Phase
    label2: Freq
    label3: Resampled Signal
    num_tabs: '4'
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: spb
    taps: firdes.root_raised_cosine(nfilts, nfilts, 1.0, rolloff, 44*nfilts)
    type: ccf
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    color1: '"blue"'
    color2: '"red"'
    gui_hint: notebook@3
    label1: ''
    label2: ''
    name: Error
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    color1: '"blue"'
    color2: '"red"'
    label1: ''
    label2: ''
    name: Scope Plot
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: '"blue"'
    gui_hint: notebook@0
    label1: ''
    name: Error
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: '"blue"'
    gui_hint: notebook@2
    label1: ''
    name: Rate
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: '"blue"'
    gui_hint: notebook@1
    label1: ''
    name: Phase
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_random_source_x, '0', digital_chunks_to_symbols_xx, '0']
- [blocks_multiply_const_vxx_0, '0', channels_channel_model_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [channels_channel_model_0, '0', blocks_throttle_0, '0']
- [digital_chunks_to_symbols_xx, '0', pfb_arb_resampler_xxx_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', qtgui_time_sink_x_0_0, '0']
- [digital_pfb_clock_sync_xxx_0, '1', qtgui_time_sink_x_1, '0']
- [digital_pfb_clock_sync_xxx_0, '2', qtgui_time_sink_x_1_0, '0']
- [digital_pfb_clock_sync_xxx_0, '3', qtgui_time_sink_x_1_1, '0']
- [pfb_arb_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
