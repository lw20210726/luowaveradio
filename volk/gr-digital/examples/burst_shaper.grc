options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: burst_shaper
    output_language: python
    run_options: run
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: window_taps
  id: variable
  parameters:
    value: fft.window.hann(10)
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    filter: '"packet_len"'
    name: Float
    type: float
  states: {}
- name: blocks_tag_debug_0_0
  id: blocks_tag_debug
  parameters:
    filter: '"packet_len"'
    name: Complex
    type: complex
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: float
  states: {}
- name: blocks_tagged_stream_to_pdu_1
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    tags: '[gr.python_to_tag({''offset'':0, ''key'':pmt.intern(''packet_len''), ''value'':pmt.from_long(20), ''srcid'':pmt.intern(''vector_source'')})]'
    type: complex
    vector: '[complex(1.0), complex(-1.0)]*15'
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    tags: '[gr.python_to_tag({''offset'':0, ''key'':pmt.intern(''packet_len''), ''value'':pmt.from_long(20), ''srcid'':pmt.intern(''vector_source'')})]'
    type: float
    vector: '[1.0, -1.0]*15'
  states: {}
- name: digital_burst_shaper_xx_0
  id: digital_burst_shaper_xx
  parameters:
    insert_phasing: 'False'
    length_tag_name: '"packet_len"'
    post_padding: '5'
    pre_padding: '5'
    type: float
    window: window_taps
  states: {}
- name: digital_burst_shaper_xx_0_0
  id: digital_burst_shaper_xx
  parameters:
    insert_phasing: 'False'
    length_tag_name: '"packet_len"'
    post_padding: '5'
    pre_padding: '5'
    type: complex
    window: window_taps
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import pmt
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from luowaveradio import fft
  states: {}

connections:
- [blocks_tagged_stream_to_pdu_0, pdus, blocks_message_debug_0, print]
- [blocks_tagged_stream_to_pdu_1, pdus, blocks_message_debug_0_0, print]
- [blocks_throttle_0, '0', blocks_tag_debug_0, '0']
- [blocks_throttle_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [blocks_throttle_0_0, '0', blocks_tag_debug_0_0, '0']
- [blocks_throttle_0_0, '0', blocks_tagged_stream_to_pdu_1, '0']
- [blocks_vector_source_x_0, '0', digital_burst_shaper_xx_0_0, '0']
- [blocks_vector_source_x_0_0, '0', digital_burst_shaper_xx_0, '0']
- [digital_burst_shaper_xx_0, '0', blocks_throttle_0, '0']
- [digital_burst_shaper_xx_0_0, '0', blocks_throttle_0_0, '0']

metadata:
  file_format: 1
