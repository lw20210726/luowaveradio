options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: qtgui_tags_viewing
    output_language: python
    run_options: run
  states: {}

blocks:
- name: delay
  id: variable_qtgui_range
  parameters:
    label: Delay
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '1000'
    value: '300'
  states: {}
- name: ntaps
  id: variable_qtgui_range
  parameters:
    label: Num Taps
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '100'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '0.004'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1000'
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: int(delay)
    type: complex
  states: {}
- name: blocks_tags_strobe_0
  id: blocks_tags_strobe
  parameters:
    key: pmt.intern("strobe")
    nsamps: '10000'
    type: complex
    value: pmt.intern("TEST")
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: 50e3
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    tags: tagged_streams.make_lengthtags((1024,), (0,), "first stream")
    type: complex
    vector: '[0.85+0.5j, 0.85, 0.85, 0.85+0.5j] + (10000-4)*[0,]'
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    tags: tagged_streams.make_lengthtags((128,), (1500,), "second stream")
    type: complex
    vector: 1500*[0,] + [0.25+0j,] + (10000-1500-1)*[0,]
  states: {}
- name: blocks_vector_source_x_0_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    tags: tagged_streams.make_lengthtags((128,), (110,), "second stream")
    type: float
    vector: 10*[0,] + [0.5,] + (100-10-1)*[0,]
  states: {state: disabled}
- name: blocks_vector_source_x_0_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    tags: tagged_streams.make_lengthtags((1024,), (0,), "testing tags")
    type: float
    vector: '[-0.85,] + (100-1)*[0,]'
  states: {state: disabled}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    samp_delay: int(ntaps)
    taps: int(ntaps)*[1,]+[1,]
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from luowaveradio.digital.utils import tagged_streams
  states: {}
- name: import_2
  id: import
  parameters:
    imports: import time
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    color1: '"blue"'
    color2: '"red"'
    color3: '"green"'
    color4: '"black"'
    label1: ''
    label2: ''
    label3: ''
    label4: ''
    name: ''
    nconnections: '2'
    size: '18000'
    srate: samp_rate
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    ymax: '1.5'
    ymin: '-0.1'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    color1: '"blue"'
    color2: '"red"'
    label1: ''
    label2: ''
    name: ''
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    tr_chan: '1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: second stream
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    color1: '"blue"'
    color2: '"red"'
    color3: '"green"'
    color4: '"black"'
    gui_hint: 1,0,1,1
    label1: ''
    label2: ''
    label3: ''
    label4: ''
    name: ''
    nconnections: '2'
    size: '1536'
    srate: samp_rate
    tr_delay: '0.015'
    tr_level: '.1'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    ymax: '4.5'
    ymin: '-0.1'
  states: {}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    color1: '"blue"'
    color2: '"red"'
    gui_hint: 1,1,1,1
    label1: ''
    label2: ''
    name: ''
    size: '5100'
    srate: samp_rate
    tr_delay: '0.06'
    tr_level: '.5'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: strobe
    type: complex
    update_time: '0.001'
    ymax: '1.5'
    ymin: '-0.1'
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_1, '1']
- [blocks_add_xx_0, '0', blocks_add_xx_1, '0']
- [blocks_add_xx_0, '0', fir_filter_xxx_0, '0']
- [blocks_add_xx_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_add_xx_1, '0', qtgui_time_sink_x_0_1_0, '0']
- [blocks_delay_0, '0', blocks_add_xx_0, '1']
- [blocks_delay_0_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_tags_strobe_0, '0', blocks_delay_0, '0']
- [blocks_throttle_0, '0', blocks_add_xx_0, '0']
- [blocks_throttle_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_vector_source_x_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_vector_source_x_0_0_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_vector_source_x_0_1, '0', blocks_throttle_0_0, '0']
- [fir_filter_xxx_0, '0', blocks_delay_0_0, '0']
- [fir_filter_xxx_0, '0', qtgui_time_sink_x_0_1, '1']

metadata:
  file_format: 1
