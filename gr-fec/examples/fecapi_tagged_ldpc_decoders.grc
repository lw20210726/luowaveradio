options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: fecapi_tagged_ldpc_decoders
    output_language: python
  states: {}

blocks:
- name: G
  id: variable_ldpc_G_matrix_def
  parameters:
    filename: gr.prefix() + "/share/luowaveradio/fec/ldpc/" + "n_0100_k_0058_gen_matrix.alist"
  states: {}
- name: G_dec
  id: variable_ldpc_G_matrix_def
  parameters:
    filename: gr.prefix() + "/share/luowaveradio/fec/ldpc/" + "n_0100_k_0058_gen_matrix.alist"
  states: {}
- name: H
  id: variable_ldpc_H_matrix_def
  parameters:
    filename: gr.prefix() + "/share/luowaveradio/fec/ldpc/" + "n_0100_k_0042_gap_02.alist"
    gap: '2'
  states: {}
- name: H_dec
  id: variable_ldpc_H_matrix_def
  parameters:
    filename: gr.prefix() + "/share/luowaveradio/fec/ldpc/" + "n_0100_k_0042_gap_02.alist"
    gap: '2'
  states: {}
- name: MTU_G
  id: variable
  parameters:
    value: '1508'
  states: {}
- name: MTU_H
  id: variable
  parameters:
    value: '1512'
  states: {}
- name: frame_size_G
  id: variable
  parameters:
    value: '58'
  states: {}
- name: frame_size_H
  id: variable
  parameters:
    value: '42'
  states: {}
- name: ldpc_dec
  id: variable_ldpc_decoder_def
  parameters:
    file: gr.prefix() + "/share/luowaveradio/fec/ldpc/" + "n_0100_k_0042_gap_02.alist"
    max_iter: '50'
    ndim: '0'
    sigma: '0.5'
  states: {}
- name: ldpc_dec_G
  id: variable_ldpc_bit_flip_decoder_def
  parameters:
    matrix_object: G_dec
    max_iterations: '100'
    ndim: '0'
  states: {}
- name: ldpc_dec_H
  id: variable_ldpc_bit_flip_decoder_def
  parameters:
    matrix_object: H_dec
    max_iterations: '100'
    ndim: '0'
  states: {}
- name: ldpc_enc
  id: variable_ldpc_encoder_def
  parameters:
    file: gr.prefix() + "/share/luowaveradio/fec/ldpc/" + "n_0100_k_0042_gap_02.alist"
    ndim: '0'
  states: {}
- name: ldpc_enc_G
  id: variable_ldpc_encoder_G_def
  parameters:
    G: G
    ndim: '0'
  states: {}
- name: ldpc_enc_H
  id: variable_ldpc_encoder_H_def
  parameters:
    H: H
    ndim: '0'
  states: {}
- name: length_tag
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1_0_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1_2
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: packet_len
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: packet_len
  states: {}
- name: blocks_stream_to_tagged_stream_0_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: length_tag
    packet_len: frame_size_H
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: length_tag
    packet_len: frame_size_G
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_vector_source_x_0_1_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: 4*[0, 0, 1, 0, 3, 0, 7, 0, 15, 0, 31, 0, 63, 0, 127, 0]
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[-1, 1]'
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: '[-1, 1]'
  states: {}
- name: digital_map_bb_0_1
  id: digital_map_bb
  parameters:
    map: '[-1, 1]'
  states: {}
- name: fec_extended_tagged_decoder_0
  id: fec_extended_tagged_decoder
  parameters:
    decoder_list: ldpc_dec
    lentagname: length_tag
    mtu: MTU_H
    puncpat: puncpat
  states: {}
- name: fec_extended_tagged_decoder_0_0
  id: fec_extended_tagged_decoder
  parameters:
    decoder_list: ldpc_dec_H
    lentagname: length_tag
    mtu: MTU_H
    puncpat: puncpat
  states: {}
- name: fec_extended_tagged_decoder_0_1
  id: fec_extended_tagged_decoder
  parameters:
    decoder_list: ldpc_dec_G
    lentagname: length_tag
    mtu: MTU_G
    puncpat: puncpat
  states: {}
- name: fec_extended_tagged_encoder_0
  id: fec_extended_tagged_encoder
  parameters:
    encoder_list: ldpc_enc
    lentagname: length_tag
    mtu: MTU_H
    puncpat: puncpat
  states: {}
- name: fec_extended_tagged_encoder_0_0
  id: fec_extended_tagged_encoder
  parameters:
    encoder_list: ldpc_enc_H
    lentagname: length_tag
    mtu: MTU_H
    puncpat: puncpat
  states: {}
- name: fec_extended_tagged_encoder_0_1
  id: fec_extended_tagged_encoder
  parameters:
    encoder_list: ldpc_enc_G
    lentagname: length_tag
    mtu: MTU_G
    puncpat: puncpat
  states: {}
- name: puncpat
  id: parameter
  parameters:
    value: '''11'''
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    color1: '"blue"'
    color2: '"red"'
    color3: '"green"'
    label1: LDPC (alist)
    label2: LDPC (H)
    label3: Input
    nconnections: '3'
    size: '2048'
    srate: samp_rate
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: length_tag
    type: float
    update_time: '0.01'
    ymax: '1.5'
    ymin: '-0.5'
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    color1: '"blue"'
    color2: '"red"'
    label1: LDPC (G)
    label2: Input
    name: '"LDPC G-definition"'
    nconnections: '2'
    size: '2048'
    srate: samp_rate
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: length_tag
    type: float
    update_time: '0.01'
    ymax: '1.5'
    ymin: '-0.5'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: source
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: source
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: source
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_char_to_float_1, '0', fec_extended_tagged_decoder_0_0, '0']
- [blocks_char_to_float_1_0, '0', qtgui_time_sink_x_1, '1']
- [blocks_char_to_float_1_0_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_char_to_float_1_0_0_0, '0', qtgui_time_sink_x_1, '2']
- [blocks_char_to_float_1_0_0_0_0, '0', qtgui_time_sink_x_1_0, '1']
- [blocks_char_to_float_1_0_1, '0', qtgui_time_sink_x_1, '0']
- [blocks_char_to_float_1_1, '0', fec_extended_tagged_decoder_0_1, '0']
- [blocks_char_to_float_1_2, '0', fec_extended_tagged_decoder_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_char_to_float_1_0_0_0, '0']
- [blocks_repack_bits_bb_0, '0', fec_extended_tagged_encoder_0, '0']
- [blocks_repack_bits_bb_0, '0', fec_extended_tagged_encoder_0_0, '0']
- [blocks_repack_bits_bb_0_0, '0', blocks_char_to_float_1_0_0_0_0, '0']
- [blocks_repack_bits_bb_0_0, '0', fec_extended_tagged_encoder_0_1, '0']
- [blocks_stream_to_tagged_stream_0_0_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_stream_to_tagged_stream_0_0_0_0, '0', blocks_repack_bits_bb_0_0, '0']
- [blocks_throttle_0, '0', virtual_sink_0, '0']
- [blocks_vector_source_x_0_1_0, '0', blocks_throttle_0, '0']
- [digital_map_bb_0, '0', blocks_char_to_float_1, '0']
- [digital_map_bb_0_0, '0', blocks_char_to_float_1_1, '0']
- [digital_map_bb_0_1, '0', blocks_char_to_float_1_2, '0']
- [fec_extended_tagged_decoder_0, '0', blocks_char_to_float_1_0_1, '0']
- [fec_extended_tagged_decoder_0_0, '0', blocks_char_to_float_1_0, '0']
- [fec_extended_tagged_decoder_0_1, '0', blocks_char_to_float_1_0_0, '0']
- [fec_extended_tagged_encoder_0, '0', digital_map_bb_0_1, '0']
- [fec_extended_tagged_encoder_0_0, '0', digital_map_bb_0, '0']
- [fec_extended_tagged_encoder_0_1, '0', digital_map_bb_0_0, '0']
- [virtual_source_0, '0', blocks_stream_to_tagged_stream_0_0_0, '0']
- [virtual_source_0_0, '0', blocks_stream_to_tagged_stream_0_0_0_0, '0']

metadata:
  file_format: 1
