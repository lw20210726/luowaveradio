options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: ber_curve_gen_ldpc
    output_language: python
  states: {}

blocks:
- name: G
  id: variable_ldpc_G_matrix_def
  parameters:
    filename: gr.prefix() +"/share/luowaveradio/fec/ldpc/simple_g_matrix.alist"
  states: {}
- name: H
  id: variable_ldpc_H_matrix_def
  parameters:
    filename: gr.prefix() + "/share/luowaveradio/fec/ldpc/n_1800_k_0902_gap_28.alist"
    gap: '28'
  states: {}
- name: dec_dummy
  id: variable_dummy_decoder_def
  parameters:
    dim1: len(esno_0)
    dim2: '1'
    framebits: framebits
    ndim: '2'
  states: {}
- name: dec_ldpc
  id: variable_ldpc_bit_flip_decoder_def
  parameters:
    dim1: len(esno_0)
    dim2: '1'
    matrix_object: H
    max_iterations: '100'
    ndim: '2'
  states: {}
- name: dec_ldpc_G
  id: variable_ldpc_bit_flip_decoder_def
  parameters:
    dim1: len(esno_0)
    dim2: '1'
    matrix_object: G
    max_iterations: '100'
    ndim: '2'
  states: {}
- name: dec_rep
  id: variable_repetition_decoder_def
  parameters:
    dim1: len(esno_0)
    dim2: '1'
    framebits: framebits
    ndim: '2'
    prob: '0.5'
    rep: '3'
  states: {}
- name: enc_dummy
  id: variable_dummy_encoder_def
  parameters:
    dim1: len(esno_0)
    dim2: '1'
    framebits: framebits
    ndim: '2'
  states: {}
- name: enc_ldpc
  id: variable_ldpc_encoder_H_def
  parameters:
    H: H
    dim1: len(esno_0)
    dim2: '1'
    ndim: '2'
  states: {}
- name: enc_ldpc_G
  id: variable_ldpc_encoder_G_def
  parameters:
    G: G
    dim1: len(esno_0)
    dim2: '1'
    ndim: '2'
  states: {}
- name: enc_rep
  id: variable_repetition_encoder_def
  parameters:
    dim1: len(esno_0)
    dim2: '1'
    framebits: framebits
    ndim: '2'
    rep: '3'
  states: {}
- name: esno_0
  id: variable
  parameters:
    value: 'numpy.arange(0, 8.1, .5) '
  states: {}
- name: framebits
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: k
  id: variable
  parameters:
    value: '7'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: '35000000'
  states: {}
- name: fec_bercurve_generator_0
  id: fec_bercurve_generator
  parameters:
    decoder_list: dec_ldpc_G
    encoder_list: enc_ldpc_G
    esno: esno_0
    puncpat: '''11'''
    samp_rate: samp_rate_0
    seed: '-100'
  states: {bus_source: true}
- name: fec_bercurve_generator_0_0
  id: fec_bercurve_generator
  parameters:
    decoder_list: dec_rep
    encoder_list: enc_rep
    esno: esno_0
    puncpat: '''11'''
    samp_rate: samp_rate_0
    seed: '-100'
  states: {bus_source: true}
- name: fec_bercurve_generator_0_0_0
  id: fec_bercurve_generator
  parameters:
    decoder_list: dec_dummy
    encoder_list: enc_dummy
    esno: esno_0
    puncpat: '''11'''
    samp_rate: samp_rate_0
    seed: '-100'
  states: {bus_source: true}
- name: fec_bercurve_generator_1
  id: fec_bercurve_generator
  parameters:
    decoder_list: dec_ldpc
    encoder_list: enc_ldpc
    esno: esno_0
    puncpat: '''11'''
    samp_rate: samp_rate_0
    seed: '-100'
  states: {bus_source: true}
- name: qtgui_bercurve_sink_0
  id: qtgui_bercurve_sink
  parameters:
    alpha1: '1'
    alpha2: '1'
    alpha3: '1'
    alpha4: '1'
    berlimit: '-10'
    berminerrors: '1000'
    color1: '"black"'
    color2: '"blue"'
    color4: '"red"'
    esno: esno_0
    label1: None
    label2: Rep. (Rate=3)
    label3: LDPC (H matrix)
    label4: LDPC (Gen. matrix)
    marker1: '8'
    marker2: '1'
    marker3: '2'
    num_curves: '4'
    style1: '3'
    style2: '2'
    style3: '4'
    width1: '2'
    width2: '2'
    width3: '2'
    width4: '2'
  states: {bus_sink: true}

connections:
- [fec_bercurve_generator_0, '34', qtgui_bercurve_sink_0, '139']
- [fec_bercurve_generator_0_0, '34', qtgui_bercurve_sink_0, '137']
- [fec_bercurve_generator_0_0_0, '34', qtgui_bercurve_sink_0, '136']
- [fec_bercurve_generator_1, '34', qtgui_bercurve_sink_0, '138']

metadata:
  file_format: 1
