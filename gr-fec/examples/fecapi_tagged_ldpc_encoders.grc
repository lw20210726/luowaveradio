options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: fecapi_tagged_ldpc_encoders
    output_language: python
  states: {}

blocks:
- name: G
  id: variable_ldpc_G_matrix_def
  parameters:
    filename: gr.prefix() + "/share/luowaveradio/fec/ldpc/" + "n_0100_k_0058_gen_matrix.alist"
  states: {}
- name: H
  id: variable_ldpc_H_matrix_def
  parameters:
    filename: gr.prefix() + "/share/luowaveradio/fec/ldpc/" + "n_0100_k_0042_gap_02.alist"
    gap: '2'
  states: {}
- name: MTU_G
  id: variable
  parameters:
    value: '1508'
  states: {}
- name: MTU_H
  id: variable
  parameters:
    value: '1512'
  states: {}
- name: frame_size_G
  id: variable
  parameters:
    value: '58'
  states: {}
- name: frame_size_H
  id: variable
  parameters:
    value: '42'
  states: {}
- name: ldpc_enc
  id: variable_ldpc_encoder_def
  parameters:
    file: gr.prefix() + "/share/luowaveradio/fec/ldpc/" + "n_0100_k_0042_gap_02.alist"
    ndim: '0'
  states: {}
- name: ldpc_enc_G
  id: variable_ldpc_encoder_G_def
  parameters:
    G: G
    ndim: '0'
  states: {}
- name: ldpc_enc_H
  id: variable_ldpc_encoder_H_def
  parameters:
    H: H
    ndim: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_1_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: pkt_len
  states: {}
- name: blocks_repack_bits_bb_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: pkt_len
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: pkt_len
    packet_len: frame_size_H
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: pkt_len
    packet_len: frame_size_G
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_vector_source_x_0_1_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (frame_size_H//16)*[0, 0, 1, 0, 3, 0, 7, 0, 15, 0, 31, 0, 63, 0, 127, 0]
  states: {}
- name: fec_extended_tagged_encoder_0
  id: fec_extended_tagged_encoder
  parameters:
    encoder_list: ldpc_enc
    lentagname: pkt_len
    mtu: MTU_H
    puncpat: puncpat
  states: {}
- name: fec_extended_tagged_encoder_0_0
  id: fec_extended_tagged_encoder
  parameters:
    encoder_list: ldpc_enc_H
    lentagname: pkt_len
    mtu: MTU_H
    puncpat: puncpat
  states: {state: disabled}
- name: fec_extended_tagged_encoder_0_0_0
  id: fec_extended_tagged_encoder
  parameters:
    encoder_list: ldpc_enc_G
    lentagname: pkt_len
    mtu: MTU_G
    puncpat: puncpat
  states: {}
- name: puncpat
  id: parameter
  parameters:
    value: '''11'''
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    alpha2: '0.6'
    color1: '"blue"'
    color2: '"red"'
    label1: LDPC (alist)
    label2: LDPC (H)
    nconnections: '2'
    size: '2048'
    srate: '1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: pkt_len
    type: float
    update_time: '0.01'
    ymax: '1.5'
    ymin: '-0.5'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    color1: '"blue"'
    label1: LDPC (G)
    size: '2048'
    srate: '1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: pkt_len
    type: float
    update_time: '0.01'
    ymax: '1.5'
    ymin: '-0.5'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: source
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: source
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: source
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_char_to_float_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_1, '0', qtgui_time_sink_x_0, '1']
- [blocks_char_to_float_1_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_char_to_float_1_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_repack_bits_bb_0_0, '0', fec_extended_tagged_encoder_0, '0']
- [blocks_repack_bits_bb_0_0, '0', fec_extended_tagged_encoder_0_0, '0']
- [blocks_repack_bits_bb_0_0_0, '0', fec_extended_tagged_encoder_0_0_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', blocks_repack_bits_bb_0_0, '0']
- [blocks_stream_to_tagged_stream_0_0_0, '0', blocks_repack_bits_bb_0_0_0, '0']
- [blocks_throttle_0, '0', virtual_sink_0, '0']
- [blocks_vector_source_x_0_1_0, '0', blocks_throttle_0, '0']
- [fec_extended_tagged_encoder_0, '0', blocks_char_to_float_1, '0']
- [fec_extended_tagged_encoder_0_0, '0', blocks_char_to_float_1_0, '0']
- [fec_extended_tagged_encoder_0_0_0, '0', blocks_char_to_float_1_0_0, '0']
- [virtual_source_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [virtual_source_0_0, '0', blocks_stream_to_tagged_stream_0_0_0, '0']

metadata:
  file_format: 1
